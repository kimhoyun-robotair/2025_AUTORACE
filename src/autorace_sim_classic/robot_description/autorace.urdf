Commit message: Add moving obstacle and marker

File: src/autorace_sim_classic/robot_description/autorace.urdf (robot description, URDF)
Before this commit: robot autorace, 11 links, 10 joints
Joints:
- joint hokuyo_joint: origin xyz=0.1 0.0 0.075 rpy=0 0 0 -> xyz=0.1 0.0 0.23 rpy=0 0 0
